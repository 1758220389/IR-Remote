# Keil uVision project IR_Remote.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IR_Remote
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GESTURE_SHADOW
  c misc: --no_multibyte_chars
  c include: .\Start;.\Library;.\Main;..\ml\firmware
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\IR_Remote.sct
  group Start
    ./Main/: startup_ir_remote.s
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h OLED.h OLED_Data.h
  group Main
    ./Main/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c bosch144.c ac_codec.c ac_gree.c ac_midea.c ac_coolix.c ac_haier.c bosch144.h ir_dma_probe.c ir_dma_probe.h ir_capture.c ir_capture.h ir_hardware.c ir_hardware.h config_store.c config_store.h flash_backend.c flash_backend.h ui.c ui.h buttons_logic.c buttons_logic.h board_keys.c board_keys.h ui_view.c ui_view.h ui_font.c ui_font.h ui_presenter.c ui_presenter.h gesture_shadow.c
    ./Library/: OLED.c OLED_Data.c
    ../ml/firmware/: gesture_recognizer.c
