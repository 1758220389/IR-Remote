# Keil uVision project GestureCapture.uvprojx, settings and files
target Gesture Capture (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GestureCapture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .;..\..\code\Start;..\..\code\Library
  memory RVCT4: ROM 0x8000000 size 0xC000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\GestureCapture.sct
  group Acquisition
    ./: main.c gesture_recognizer.c
  group Startup
    ../../code/Start/: startup_stm32f10x_md.s system_stm32f10x.c
  group SPL
    ../../code/Library/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
